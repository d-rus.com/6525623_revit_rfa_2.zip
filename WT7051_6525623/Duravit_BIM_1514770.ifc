Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Mirrors_DURAVIT_WT7051-Mirror.ifc
Time: 2021-04-23T17:13:30
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, WT7051 Mirror
ePset_BIMobjectScript - Color: White Matt; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): WT7051 Mirror; SKU (BO_prodsku): white-tulip-mirror-wt7051; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): White Tulip; ProductGroup (BO_prodgroup): Mirror / Mirror cabinets; EditionNumber (BO_edinum): 1; Width (BO_width): 750; Height (BO_height): 750; Depth (BO_depth): 50; Weight (BO_weight): 10; QR (BO_boqrurl): http://bimobject.com/duravit/product/white-tulip-mirror-wt7051; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/white-tulip-mirror-wt7051; ProductUrl (BO_producturl): https://duravit-public-assets.s3.eu-central-1.amazonaws.com/1/4/Duravit_PI-HI_WT7051__1415205.jpg; GtinCode (BO_gtin): 4063382123954; MaterialMain (BO_mainmat): Mirror Glass; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Mirrors; BimObjectCategoryCode (BO_bocat_code): sanitary-mirrors; IfcClassification (BO_ifcclas): Furnishing Element; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8732; Uniclass14Description (BO_uniclass_1_4_desc): Mirrors; Uniclass20Code (BO_uniclass_2_0_code): PR-45-55-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathroom Mirrors; Uniclass2015Code (BO_uniclass2015_code): Pr_25_71_53_06; Uniclass2015Description (BO_uniclass2015_desc): Bathroom mirrors; NBSReference (BO_nbs_ref): 45-55-06; NBSReferenceDescription (BO_nbs_desc): Bathroom Mirrors; OmniClassCode (BO_omniclass_code): 23-21 37 13 15; OmniClassDescription (BO_omniclass_name): Mirrors; MasterFormat2014Code (BO_masterformat2014_code): 08 83 00; MasterFormat2014Description (BO_masterformat2014_name): Mirrors; UniFormat2Code (BO_uniformat2_code): E20; UniFormat2Description (BO_uniformat2_name): FURNISHINGS; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
